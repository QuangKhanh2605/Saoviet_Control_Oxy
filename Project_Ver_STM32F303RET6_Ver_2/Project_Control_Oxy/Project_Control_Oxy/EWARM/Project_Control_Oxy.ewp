# IAR project Project_Control_Oxy.ewp, settings and files
configuration Project_Control_Oxy (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303RE ST STM32F303RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F303xE
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc; ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32F3xx/Include; ../Drivers/CMSIS/Include; ..\user_app\user_app_common; ..\user_app\user_app_oxygen; ..\user_app\user_app_oxygen\user_app_button; ..\user_app\user_app_oxygen\user_app_ctrl_oxy; ..\user_app\user_app_oxygen\user_app_lcd; ..\user_app\user_app_oxygen\user_app_menu_display; ..\user_app\user_app_oxygen\user_app_relay; ..\user_app\user_app_oxygen\user_app_rs485; ..\user_app\user_app_mem; ..\user_app\user_app_sim; ..\user_app\user_at_serial; ..\user_app\user_log; ..\user_app\user_uart; ..\user_component\mqtt_lib\inc; ..\user_component\user_convert_variable; ..\user_component\user_lcd\lcd_lcd12864j; ..\user_component\user_mem; ..\user_component\user_mem\user_external_eeprom\user_cat24; ..\user_component\user_mem\user_external_eeprom; ..\user_component\user_mem\user_internal_mem; ..\user_component\user_sim\user_ec200u; ..\user_component\user_sim; ..\user_eventdriven; ..\user_queue; ..\user_timer; ..\user_util; ..\user_app\user_app_oxygen\user_app_ctrl_pH; ..\user_app\user_app_oxygen\user_app_rs485_slave
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project_Control_Oxy.bin
  ILINK.IlinkOutputFile: Project_Control_Oxy.out
  ILINK.IlinkIcfFile: stm32f303xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f303xe.s
  group Application/User/Core
    ../Core/Src/: dma.c gpio.c i2c.c iwdg.c main.c rtc.c stm32f3xx_hal_msp.c stm32f3xx_it.c usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f3xx.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_exti.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_iwdg.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_rtc.c stm32f3xx_hal_rtc_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c
  group user_app/user_app_common
    ../user_app/user_app_common/: user_app_comm.c user_app_comm.h user_define.h user_modem.c user_modem.h user_modem_init.c user_modem_init.h
  group user_app/user_app_ctrl_pH
    ../user_app/user_app_oxygen/user_app_ctrl_pH/: user_app_ctrl_pH.c user_app_ctrl_pH.h
  group user_app/user_app_mem
    ../user_app/user_app_mem/: user_app_mem.c user_app_mem.h
  group user_app/user_app_oxygen
    ../user_app/user_app_oxygen/: user_define_oxygen.c user_define_oxygen.h
  group user_app/user_app_oxygen/user_app_button
    ../user_app/user_app_oxygen/user_app_button/: user_app_button.c user_app_button.h
  group user_app/user_app_oxygen/user_app_ctrl_oxy
    ../user_app/user_app_oxygen/user_app_ctrl_oxy/: user_app_ctrl_oxy.c user_app_ctrl_oxy.h
  group user_app/user_app_oxygen/user_app_lcd
    ../user_app/user_app_oxygen/user_app_lcd/: user_app_lcd.c user_app_lcd.h
  group user_app/user_app_oxygen/user_app_menu_display
    ../user_app/user_app_oxygen/user_app_menu_display/: user_app_menu_display.c user_app_menu_display.h
  group user_app/user_app_oxygen/user_app_relay
    ../user_app/user_app_oxygen/user_app_relay/: user_app_relay.c user_app_relay.h
  group user_app/user_app_oxygen/user_app_rs485
    ../user_app/user_app_oxygen/user_app_rs485/: user_app_rs485.c user_app_rs485.h
  group user_app/user_app_oxygen/user_app_rs485_slave
    ../user_app/user_app_oxygen/user_app_rs485_slave/: user_app_rs485_slave.c user_app_rs485_slave.h
  group user_app/user_app_sim
    ../user_app/user_app_sim/: user_app_sim.c user_app_sim.h user_mqtt.c user_mqtt.h
  group user_app/user_at_serial
    ../user_app/user_at_serial/: user_at_serial.c user_at_serial.h
  group user_app/user_log
    ../user_app/user_log/: user_log.c user_log.h
  group user_app/user_uart
    ../user_app/user_uart/: user_uart.c user_uart.h
  group user_component/mqtt_lib
    ../user_component/mqtt_lib/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
  group user_component/user_convert_variable
    ../user_component/user_convert_variable/: user_convert_variable.c user_convert_variable.h
  group user_component/user_lcd/lcd_lcm12864j
    ../user_component/user_lcd/lcd_lcd12864j/: GLCD192x64.c GLCD192x64.h
  group user_component/user_mem
    ../user_component/user_mem/: user_mem_comm.h
  group user_component/user_mem/user_external_eeprom
    ../user_component/user_mem/user_external_eeprom/: user_external_eeprom.c user_external_eeprom.h
  group user_component/user_mem/user_external_eeprom/user_cat24
    ../user_component/user_mem/user_external_eeprom/user_cat24/: cat24mxx.c cat24mxx.h
  group user_component/user_mem/user_internal_mem
    ../user_component/user_mem/user_internal_mem/: user_internal_mem.c user_internal_mem.h
  group user_component/user_sim
    ../user_component/user_sim/: user_sim.c user_sim.h user_sim_common.c user_sim_common.h
  group user_component/user_sim/user_ec200u
    ../user_component/user_sim/user_ec200u/: user_ec200u.c user_ec200u.h
  group user_eventdriven
    ../user_eventdriven/: event_driven.c event_driven.h
  group user_queue
    ../user_queue/: queue_p.c queue_p.h
  group user_timer
    ../user_timer/: user_rtc.c user_rtc.h user_timer.c user_timer.h
  group user_util
    ../user_util/: onchipflash.c onchipflash.h user_lpm.c user_lpm.h user_modbus_rtu.c user_modbus_rtu.h user_obis_sv.c user_obis_sv.h user_string.c user_string.h user_time.c user_time.h user_util.c user_util.h

<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Project_Control_Oxy.ewp</path>
  </project>
  <batchBuild />
</workspace>

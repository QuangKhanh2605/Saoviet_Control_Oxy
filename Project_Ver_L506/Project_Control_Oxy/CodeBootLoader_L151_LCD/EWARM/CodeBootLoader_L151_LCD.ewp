# IAR project CodeBootLoader_L151_LCD.ewp, settings and files
configuration CodeBootLoader_L151_LCD (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151RC ST STM32L151RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L151xC
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L1xx/Include; ../Drivers/CMSIS/Include; ..\user_lcd\lcd_lcd12864j; ..\user_lib
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CodeBootLoader_L151_LCD.hex
  ILINK.IlinkOutputFile: CodeBootLoader_L151_LCD.out
  ILINK.IlinkIcfFile: stm32l151xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l151xc.s
  group Application/User/Core
    ../Core/Src/: gpio.c main.c stm32l1xx_hal_msp.c stm32l1xx_it.c usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_exti.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c
  group user_lcd/lcd_lcd12864j
    ../user_lcd/lcd_lcd12864j/: GLCD192x64.c GLCD192x64.h
  group user_lib
    ../user_lib/: event_driven.c event_driven.h onchipflash.c onchipflash.h queue_p.c queue_p.h user_internal_mem.c user_internal_mem.h user_mem_comm.h user_util.c user_util.h

<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\CodeBootLoader_F303.ewp</path>
  </project>
  <batchBuild />
</workspace>

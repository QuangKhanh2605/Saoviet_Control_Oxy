# IAR project Project_Slave_Control_Motor.ewp, settings and files
configuration Project_Slave_Control_Motor (ARM, debug)
  General.OGChipSelectEditMenu: STM32L151RC ST STM32L151RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L151xC
  ICCARM.CCIncludePath2: ../Core/Inc; ../USB_DEVICE/App; ../USB_DEVICE/Target; ../Drivers/STM32L1xx_HAL_Driver/Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; ../Drivers/CMSIS/Device/ST/STM32L1xx/Include; ../Drivers/CMSIS/Include; ..\user_util; ..\user_timer; ..\user_queue; ..\user_eventdriven; ..\user_component\mqtt_lib\inc; ..\user_component\user_convert_variable; ..\user_component\user_lcd\lcd_16x2; ..\user_component\user_mem\user_external_eeprom\user_cat24; ..\user_component\user_mem\user_external_eeprom; ..\user_component\user_mem\user_internal_mem; ..\user_component\user_mem; ..\user_app\user_app_common; ..\user_app\user_app_mem; ..\user_app\user_at_serial; ..\user_app\user_log; ..\user_app\user_uart; ..\user_app\user_app_slave_motor\user_app_button; ..\user_app\user_app_slave_motor; ..\user_app\user_app_slave_motor\user_app_motor; ..\user_app\user_app_slave_motor\user_app_menu_display; ..\user_app\user_app_slave_motor\user_app_lcd; ..\user_app\user_app_slave_motor\user_app_rs485
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project_Slave_Control_Motor.hex
  ILINK.IlinkOutputFile: Project_Slave_Control_Motor.out
  ILINK.IlinkIcfFile: stm32l151xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l151xc.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c i2c.c iwdg.c rtc.c tim.c usart.c stm32l1xx_it.c stm32l1xx_hal_msp.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_pcd.c stm32l1xx_hal_pcd_ex.c stm32l1xx_ll_usb.c stm32l1xx_hal.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_dma.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_cortex.c stm32l1xx_hal_exti.c stm32l1xx_hal_adc.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_i2c.c stm32l1xx_hal_iwdg.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c stm32l1xx_hal_uart.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group user_app/user_app_common
    ../user_app/user_app_common/: user_app_comm.c user_app_comm.h user_define.h user_modem.c user_modem.h user_modem_init.c user_modem_init.h
  group user_app/user_app_mem
    ../user_app/user_app_mem/: user_app_mem.c user_app_mem.h
  group user_app/user_app_slave_motor
    ../user_app/user_app_slave_motor/: user_define_slave_motor.c user_define_slave_motor.h
  group user_app/user_app_slave_motor/user_app_button
    ../user_app/user_app_slave_motor/user_app_button/: user_app_button.c user_app_button.h
  group user_app/user_app_slave_motor/user_app_lcd
    ../user_app/user_app_slave_motor/user_app_lcd/: user_app_lcd.c user_app_lcd.h
  group user_app/user_app_slave_motor/user_app_menu_display
    ../user_app/user_app_slave_motor/user_app_menu_display/: user_app_menu_display.c user_app_menu_display.h
  group user_app/user_app_slave_motor/user_app_motor
    ../user_app/user_app_slave_motor/user_app_motor/: user_app_motor.c user_app_motor.h
  group user_app/user_app_slave_motor/user_app_rs485
    ../user_app/user_app_slave_motor/user_app_rs485/: user_app_rs485.c user_app_rs485.h
  group user_app/user_at_serial
    ../user_app/user_at_serial/: user_at_serial.c user_at_serial.h
  group user_app/user_log
    ../user_app/user_log/: user_log.c user_log.h
  group user_app/user_uart
    ../user_app/user_uart/: user_uart.c user_uart.h
  group user_component/user_convert_variable
    ../user_component/user_convert_variable/: user_convert_variable.c user_convert_variable.h
  group user_component/user_lcd/lcd_16x2
    ../user_component/user_lcd/lcd_16x2/: CLCD.c CLCD.h
  group user_component/user_mem
    ../user_component/user_mem/: user_mem_comm.h
  group user_component/user_mem/user_external_eeprom
    ../user_component/user_mem/user_external_eeprom/: user_external_eeprom.c user_external_eeprom.h
  group user_component/user_mem/user_external_eeprom/user_cat24
    ../user_component/user_mem/user_external_eeprom/user_cat24/: cat24mxx.c cat24mxx.h
  group user_component/user_mem/user_internal_mem
    ../user_component/user_mem/user_internal_mem/: user_internal_mem.c user_internal_mem.h
  group user_eventdriven
    ../user_eventdriven/: event_driven.c event_driven.h
  group user_queue
    ../user_queue/: queue_p.c queue_p.h
  group user_timer
    ../user_timer/: user_rtc.c user_rtc.h user_timer.c user_timer.h
  group user_util
    ../user_util/: onchipflash.c onchipflash.h user_adc.c user_adc.h user_lpm.c user_lpm.h user_modbus_rtu.c user_modbus_rtu.h user_obis_sv.c user_obis_sv.h user_string.c user_string.h user_time.c user_time.h user_util.c user_util.h
